## Kconfig
```kconfig
config LAYER_LEDS
    bool "Enable caps lock LED indicator module"
    default y
```
